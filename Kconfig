## Kconfig
```kconfig
config MT7612U
	tristate "Mediatek/Ralink MT7612U USB Wi-Fi driver"
	depends on USB
	---help---
	  From git://github.com/ulli-kroll/mt7612u.git master
```
